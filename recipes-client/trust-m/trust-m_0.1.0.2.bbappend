FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Changed-GPIO-pins-and-I2C-bus-to-work-with-rzg3e-ea-.patch;patchdir=trustm_lib"

